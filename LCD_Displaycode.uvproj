# Keil uVision project LCD_Displaycode.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD_Displaycode +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: fileLCDcode.c ThuvienLCD.c ThuvienLCd.h Real_Time_DS1307.c
